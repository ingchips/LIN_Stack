# Keil uVision project lin_stack_master_916xx.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: lin_stack_master_916xx +hex
  AfterMake: fromelf.exe --bin -o lin_stack_master_916xx.bin ./output/lin_stack_master_916xx.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,  BOARD_ID=BOARD_DB72C8K1A, BOARD_USE_RGB_LED
  c include: ../../../../../ING918XX_SDK_SOURCE/bundles/typical/inc;../../../../../ING918XX_SDK_SOURCE/bundles/typical/inc/os;../../../../../ING918XX_SDK_SOURCE/src/BSP;../../../../../ING918XX_SDK_SOURCE/src/FWlib;../../../../../ING918XX_SDK_SOURCE/src/StartUP/ing916;../../../../../ING918XX_SDK_SOURCE/src/Tools;../../../../../ING918XX_SDK_SOURCE/src;..\..\..\src\lin_drv;..\..\..\src\lin_drv\drv_api;..\..\..\src\lin_drv\drv_hw;..\..\..\src\platform_supplement;..\src;..\src\lin_cfg;..\..\..\src\lin_stack_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x200053c8 size 0x2c38
  group APP
    ../src/: main.c profile.c lin_stack_task.c lin_user_def.h
  group platform_supplement
    ../../../src/platform_supplement/: key.c gpio_irq_management.c
  group StartUP
    ../src/: startup_ing91600.s
    ../../../../../ING918XX_SDK_SOURCE/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../../../../ING918XX_SDK_SOURCE/src/BSP/: eflash.c board.c
  group FWlib
    ../../../../../ING918XX_SDK_SOURCE/src/FWlib/: peripheral_uart.c peripheral_timer.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_gpio.c peripheral_pwm.c
  group Tools
    ../../../../../ING918XX_SDK_SOURCE/src/Tools/: trace.c
  group lin_driver
    ../../../src/lin_drv/: lin_common.c lin_driver.c lin_irq.c lin_lpuart_driver.c osif.c peripherals_lin_0.c ING91XXX.h
    ../../../src/lin_drv/drv_hw/: clock_hw_access.c gpio_hw_access.c irq_hw_access.c lpuart_hw_access.c timer_hw_access.c
  group lin_cfg
    ../src/lin_cfg/: lin_cfg.c
  group lin_stack
    ../../../src/lin_stack_lib/: lin_stack_master_lib.lib
software components: CMSIS:CORE 4.3.0
